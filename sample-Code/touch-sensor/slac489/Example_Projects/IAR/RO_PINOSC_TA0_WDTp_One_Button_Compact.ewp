# IAR project RO_PINOSC_TA0_WDTp_One_Button_Compact.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430G2452 MSP430G2452
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: __MSP430G2452__
  ICC430.newCCIncludePaths: ..\Source\RO_PINOSC_TA0_WDTp_One_Button_Compact\; ..\..\Library\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2452.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  ICC430.CCDefines: NDEBUG; __MSP430G2452__
  ICC430.newCCIncludePaths: ..\Examples\RO_PINOSC_TA0_WDTp_One_Button_Compact\; ..\Library\
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  group Application
    ../Source/RO_PINOSC_TA0_WDTp_One_Button_Compact/: main.c structure.c structure.h
  group Library
    ../../Library/: CTS_HAL.c CTS_HAL.h CTS_Layer.c CTS_Layer.h
